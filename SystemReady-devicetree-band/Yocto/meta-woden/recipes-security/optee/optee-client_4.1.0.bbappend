EXTRA_OECMAKE:pn-optee-client:append:genericarm64 = " -DRPMB_EMU=0"
