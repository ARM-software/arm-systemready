EXTRA_OECMAKE:pn-optee-client:append:generic-arm64 = " -DRPMB_EMU=0"
