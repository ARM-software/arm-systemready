FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:generic-arm64 = " file://systemready.cfg"
